# Keil uVision project SpaceInvaders.uvproj, settings and files
target SpaceInvaders (ARM-ADS)
  device: TM4C123GE6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x1FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: SpaceInvaders
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Nokia5110.c random.s SpaceInvaders.c TExaS.c DAC.c Sound.c ADC.c GameEngine.c SwitchLed.c
